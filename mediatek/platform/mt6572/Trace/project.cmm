global &project
&project="mt6589_evb1"
